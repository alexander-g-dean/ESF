# Keil uVision project Analog.uvprojx, settings and files
target KL25Z Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.14.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Analog
  c flags: Optim=1
  c include: inc;C:\Keil_v5\ARM\Pack\Keil\Kinetis_KLxx_DFP\1.13.0\Device\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Files
    ./src/: LEDs.c main.c timers.c
software components: CMSIS:CORE 5.0.2, Device:Startup 2.5.0
